ORG 00h
MOV 30H, #1fH
ACALL HEX2BIN 
HERE: SJMP HERE

HEX2BIN:	
	MOV B, 30H
	MOV A, #0F0H
	ANL A, B
	SWAP A
	CJNE A, #09H, NOTEQ1
LEQ1:MOV R1, #30H
	ADD A, R1
	MOV 60H, A
	SJMP RES1
NOTEQ1:JC LEQ1
GEQ1:MOV R1,#40H
	SUBB A,#09H
	ADD A, R1
	MOV 60H, A
RES1:MOV A, #0FH
	ANL A, B
	CJNE A, #09H, NOTEQ2
LEQ2:MOV R1, #30H
	ADD A, R1
	MOV 61H, A
	SJMP RES2
NOTEQ2:JC LEQ2
GEQ2:MOV R1,#40H
	SUBB A,#09H
	ADD A, R1
	MOV 61H, A
RES2:
RET

END