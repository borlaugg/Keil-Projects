// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAC
HERE: SJMP HERE
ORG 130H
// *****************
MAC:
// MAC OPERATION, CALL THE ADDITION SUBROUTINE USING "CALL ADD16"
MOV	A, 70H
MOV B, 73H
MUL AB
MOV 70H, A
MOV 73H, B
MOV	A, 71H
MOV B, 74H
MUL AB
MOV 71H, A
MOV 74H, B
CALL ADD16
MOV	A, 72H
MOV B, 75H
MUL AB
MOV 71H, A
MOV 74H, B
CALL ADD16
MOV 50H, 76H
MOV 51H, 73H
MOV 52H, 70H
RET
ADD16:
//16 BIT ADDITION CODE
MOV A, 70H
CLR C
ADD A, 71H
MOV 70H, A
MOV A, 73H
ADDC A, 74H
MOV 73H, A
CLR A
JC CARRY
SJMP NEXT
CARRY: MOV A, #1
NEXT: ADD A,76H
MOV 76H, A
RET
END