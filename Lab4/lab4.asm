ORG 0
MAIN:MOV R1, 50H
	ACALL DISPLAY
	MOV R1, 51H
	ACALL DISPLAY
	MOV R1, 52H
	ACALL DISPLAY
	MOV R1, 53H
	ACALL DISPLAY
	SJMP MAIN

ORG 200
DISPLAY: MOV A, #0F0H
	ANL A, R1
	MOV P1, A
	ACALL DELAY_200ms
	MOV A, #0FH
	ANL A, R1
	SWAP A
	MOV P1, A
	ACALL DELAY_200ms
	MOV P1, #0FFH
	ACALL DELAY_200ms
	RET

DELAY_1s:PUSH 00h 
	MOV R6, #100 
	h4: ACALL DELAY_10ms 
	DJNZ R6, h4
	POP 00h 
	RET

DELAY_200ms: PUSH 00h
	MOV R5, #20
	h3: ACALL DELAY_10ms 
	DJNZ R5, h3 
	POP 00h 
	RET
	
DELAY_10ms:PUSH 00h 
	MOV R6, #40 
	h2: ACALL delay_250us 
	DJNZ R6, h2 
	POP 00h 
	RET

delay_250us: push 00h 
	mov r7, #244 
	h1: djnz r7, h1 
	pop 00h 
	ret

END